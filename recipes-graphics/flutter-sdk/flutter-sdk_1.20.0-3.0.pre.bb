require flutter-sdk.inc

LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://LICENSE;md5=1d84cf16c48e571923f837136633a265"

SRC_URI = "https://storage.googleapis.com/flutter_infra/releases/dev/linux/flutter_linux_1.20.0-3.0.pre-dev.tar.xz"
SRC_URI[md5sum] = "0e9d72673c6a5dde91ff0c5fbfe484f5"
