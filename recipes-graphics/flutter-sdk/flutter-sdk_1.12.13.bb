require flutter-sdk.inc

LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://LICENSE;md5=343c5a032261c8c32d621412cdcd70a8"

SRC_URI = "https://storage.googleapis.com/flutter_infra/releases/stable/linux/flutter_linux_v1.12.13+hotfix.9-stable.tar.xz"
SRC_URI[md5sum] = "52f21a77670556a4db5f668dac3adb3b"
